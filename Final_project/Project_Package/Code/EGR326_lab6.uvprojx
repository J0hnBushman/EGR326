# Keil uVision project EGR326_lab6.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EGR326_lab6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: bitmap_typedefs.h font_firacode_regular_14.h font_fixedsys_mono_16.h font_fixedsys_mono_24.h font_freemono_mono_24.h font_freemono_mono_bold_24.h font_microsoft_16.h font_ubuntu_48.h font_ubuntu_mono_24.h ILI9341.h my_photos.h RccConfig.h spi.h ILI9341.c RccConfig.c spi.c testmain.c hall.h hall.c TIMERS.c TIMERS.h stepper.c stepper.h I2C.c I2C.h main.h rotary_encoder.c rotary_encoder.h btn.c btn.h Sonar.c Sonar.h servo.c servo.h ADC.c ADC.h health_bar.h health_bar.c sevenSeg.c sevenSeg.h Piezo.h Piezo.c
software components: CMSIS:CORE 6.1.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 2.6.3
